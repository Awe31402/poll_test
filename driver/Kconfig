## driver/Kconfig
```kconfig
config DEVONE
    tristate "Devone Device"
    default n
    help
    This is Devone dev experimental module
```
